## app/boards/our_board/board.yml
```yaml
board:
  name: our_board
  full_name: our_board
  vendor: st
  socs:
    - name: stm32f446xx
```
